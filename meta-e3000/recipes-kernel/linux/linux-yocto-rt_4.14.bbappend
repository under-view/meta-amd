require linux-yocto-e3000_4.14.inc
