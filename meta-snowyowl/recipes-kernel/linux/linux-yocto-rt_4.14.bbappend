require linux-yocto-snowyowl_4.14.inc
