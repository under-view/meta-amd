# We do not support Video4Linux
PACKAGECONFIG_remove_v1000 = " v4l libv4l"
