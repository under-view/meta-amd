require linux-yocto-r1000_4.19.inc

SRC_URI_append_r1000 = " file://r1000-standard-only.cfg"

