SRCREV_r1000 = "5a3bdc7add2f30f7673052376514c91dbcd1b64a"
SRC_URI_remove_r1000 = "file://0001-headers-sync-up-amdgpu_drm.h-with-drm-next.patch"
