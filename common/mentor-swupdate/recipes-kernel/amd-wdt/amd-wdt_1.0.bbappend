FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SRC_URI_append = "file://0001-amd-wdt-do-not-stop-wdt-as-swupdate-implementation-n.patch"
