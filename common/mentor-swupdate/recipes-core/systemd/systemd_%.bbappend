pkg_postinst_ontarget_udev-hwdb_amd () {
}
