python () {
    d.setVar('pkg_postinst_ontarget_libomxil', '')
}
