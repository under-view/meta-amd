FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SRC_URI_append_mel-lite = " file://gnulib.patch"
