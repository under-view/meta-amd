FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SRC_URI_append_mel-lite = " file://m4-1.4.18-glibc-change-work-around.patch"
