FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SRC_URI_append_mel-lite = " file://0001-include-sys-sysmacros.h-for-major-minor.patch"
