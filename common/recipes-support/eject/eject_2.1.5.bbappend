FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SRC_URI_append_mel-lite = " file://0001-eject-Include-sys-sysmacros.h-for-major-minor.patch"
