FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SRC_URI_append_mel-lite = " file://fix-fseterr-for-glibc-2.28.patch"
