FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SRC_URI_append_mel-lite = " file://0001-geom-sysfs-fix-build-with-glibc-2.28.patch"
