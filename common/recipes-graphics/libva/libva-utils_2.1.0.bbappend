DEPENDS_append_amd = " libva-x11"
