require linux-yocto-5.15.inc

PR := "${INC_PR}.0"

KBRANCH:amd ?= "v5.15/standard/base"
SRCREV_machine:amd ?= "0e51e571701842db33ad96f6ddc8cc6b23230627"
