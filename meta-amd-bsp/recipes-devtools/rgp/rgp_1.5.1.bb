require rgp.inc

LIC_FILES_CHKSUM = "file://License.rtf;md5=72fe1cfaa4cab2caf95a7a0ccd8a7ddd"
