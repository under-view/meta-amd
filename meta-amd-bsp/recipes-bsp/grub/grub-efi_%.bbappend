require grub-fixes.inc

RDEPENDS_${PN}_class-target_append = " efibootmgr"
