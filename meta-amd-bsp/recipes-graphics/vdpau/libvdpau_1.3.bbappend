EXTRA_OECONF += "--enable-dri2"
