FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-libglu-src-libutil-error.c-add-missing-include-stdde.patch"
